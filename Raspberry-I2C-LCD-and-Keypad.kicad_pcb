# Repository cbaurtx/Raspberry-I2C-LCD-and-Keypad

File README.md:

# Raspberry-I2C-LCD-and-Keypad
LCD Display and Keypad controller connected to Raspberry Pi via i2c
KiCAD (http://www.kicad-pcb.org) is used for schematics and PCB layout

Connection to the Raspberry Pi:

RasPi pin | Keypad / LCD Signal|Description
----------|--------------------|-----------
2|5V|power
3|SCL|serial clock
6|SDG|serial ground / shield
5|SDA|serial data
6|GND|ground
12|INT|interrupt

You can populate the PCB partially if only the LCD display or the keypad
controller is needed.

Blockdiagramm

Raspberry interface

Display:

Keypad:

Created using KiCAD 5.1.3
Conceived using information from: https://5volt-junkie.net/i2c-keypad/

## KiCad design Raspberry-I2C-LCD-and-Keypad.kicad_pcb

Parts:
C1: 100n; C_Disc_D5.0mm_W2.5mm_P2.50mm
C2: 10µ; CP_Radial_Tantal_D4.5mm_P2.50mm
D1: green; LED_D3.0mm_Horizontal_O3.81mm_Z2.0mm
JP1, JP2, JP3: Jumper_NC_Dual; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm_NumberLabels
Q20: BC557; TO-92_Horizontal1
R1: 4k7; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R2: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R3: 180; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
RV1: 10k; Potentiometer_Vishay_43_Horizontal
U20: PCF8574A; DIP-16_W7.62mm
U21: LCD_HD44780; QC2004A

Connections:
+3V3: C1.2, JP1.3, JP2.3, JP3.3, U20.16 (VDD); also elsewhere on the board
/DisplayController/5V: C2.1, Q20.3 (E), R1.2, RV1.3, U21.2 (Vcc); also elsewhere on the board
/DisplayController/GND: C1.1, C2.2, JP1.1, JP2.1, JP3.1, RV1.1, U20.8 (VSS), U21.1 (GND), U21.16 (BL-); also elsewhere on the board
/DisplayController/SCL: U20.14 (SCL); also elsewhere on the board
/DisplayController/SDA: U20.15 (SDA); also elsewhere on the board
unnamed: D1.1 (K), R2.2
unnamed: D1.2 (A), Q20.2 (B), R1.1
unnamed: JP1.2, U20.1 (A0)
unnamed: JP2.2, U20.2 (A1)
unnamed: JP3.2, U20.3 (A2)
unnamed: Q20.1 (C), R3.2
unnamed: R2.1, U20.12 (P7)
unnamed: R3.1, U21.15 (BL+)
unnamed: RV1.2, U21.3 (VC)
unnamed: U20.4 (P0), U21.11 (DB4/0)
unnamed: U20.5 (P1), U21.12 (DB5/1)
unnamed: U20.6 (P2), U21.13 (DB6/2)
unnamed: U20.7 (P3), U21.14 (DB7/3)
unnamed: U20.9 (P4), U21.4 (RS)
unnamed: U20.10 (P5), U21.5 (R/~W)
unnamed: U20.11 (P6), U21.6 (E)

Parts:
C3, C4: 100n; C_Disc_D5.0mm_W2.5mm_P2.50mm
J1: Conn_01x06; PinHeader_1x06_P1.27mm_Horizontal
U3: AP2204R-3.3; SOT-89-3

Connections:
+3V3: C4.1, U3.3 (VOUT); also elsewhere on the board
/DisplayController/5V: C3.1, J1.1, U3.1 (VIN); also elsewhere on the board
/DisplayController/GND: C3.2, C4.2, J1.6, U3.2 (GND); also elsewhere on the board
/DisplayController/SCL: J1.4; also elsewhere on the board
/DisplayController/SDA: J1.2; also elsewhere on the board
/DisplayController/SDG: J1.3
/KeypadController/~INT: J1.5; also elsewhere on the board

Notes on the sheet:
SDG denotes shield for i2c bus

Parts:
C5: 100n; C_Disc_D5.0mm_W2.5mm_P5.00mm
J2, J3, J4: Conn_01x08; PinHeader_1x08_P1.27mm_Horizontal
RN1: 10k; R_Array_SIP9
U4: TCA8418; QFN-24-1EP_4x4mm_P0.5mm_EP2.65x2.65mm

Connections:
+3V3: C5.1, J3.1, RN1.1 (common), U4.21 (Vcc); also elsewhere on the board
/DisplayController/GND: C5.2, J3.8, U4.19 (GND); also elsewhere on the board
/DisplayController/SCL: U4.23 (SCL); also elsewhere on the board
/DisplayController/SDA: U4.22 (SDA); also elsewhere on the board
/KeypadController/~INT: U4.24 (~Int); also elsewhere on the board
/KeypadController/~RES: RN1.8 (R7), U4.20 (~Reset)
unnamed: J2.1, J4.1, U4.8 (ROW0)
unnamed: J2.2, J4.2, U4.7 (ROW1)
unnamed: J2.3, J4.3, U4.6 (ROW2)
unnamed: J2.4, J4.4, U4.5 (ROW3)
unnamed: J2.5, U4.9 (COL0)
unnamed: J2.6, U4.10 (COL1)
unnamed: J2.7, U4.11 (COL2)
unnamed: J2.8, U4.12 (COL3)
unnamed: J3.2, RN1.2 (R1), U4.4 (ROW4)
unnamed: J3.3, RN1.3 (R2), U4.3 (ROW5)
unnamed: J3.4, RN1.4 (R3), U4.2 (ROW6)
unnamed: J3.5, RN1.5 (R4), U4.1 (ROW7)
unnamed: J3.6, RN1.6 (R5), U4.17 (COL8)
unnamed: J3.7, RN1.7 (R6), U4.18 (COL9)
unnamed: J4.5, U4.13 (COL4)
unnamed: J4.6, U4.14 (COL5)
unnamed: J4.7, U4.15 (COL6)
unnamed: J4.8, U4.16 (COL7)

Notes on the sheet:
Keypad1 16 Keys
Keypad2 16 Keys
GPIO1 8 IO

Board: 2 copper layers, 100.3 x 62.2 mm, 23 parts (2 on the bottom side), 41 nets.

## Commit log

2019-07-25 modified: README.md
2019-07-25 new file: DisplayController.sch new file: KeypadController.sch new file: RasPiInterface.bck new file: RasPiInterface.dcm new file: RasPiInterface.lib new file: RasPiInterface.sch new file: Raspberry-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
2019-07-26 modified: DisplayController.sch modified: KeypadController.sch new file: QC2004A.kicad_mod modified: RasPiInterface.lib modified: RasPiInterface.sch new file: Raspberry-I2C-LCD-and-Keypad-B_Cu.gbr ne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
2019-07-26 modified: QC2004A.kicad_mod deleted: RasPiInterface.bck deleted: RasPiInterface.dcm modified: RasPiInterface.lib deleted: Raspberry-I2C-LCD-and-Keypad-B_Paste.gbr deleted: Raspberry-I2C-LCD-and-Keypa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
2019-07-26 modified: Raspberry-I2C-LCD-and-Keypad.kicad_pcb new file: build/Raspberry-I2C-LCD-and-Keypad-B_Cu.gbr new file: build/Raspberry-I2C-LCD-and-Keypad-B_Mask.gbr new file: build/Raspberry-I2C-LCD-and-Ke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
2019-07-26 deleted: Raspberry-I2C-LCD-and-Keypad.kicad_pcb-bak
2019-07-26 deleted: build/Raspberry-I2C-LCD-and-Keypad-B_Cu.gbr deleted: build/Raspberry-I2C-LCD-and-Keypad-B_Mask.gbr deleted: build/Raspberry-I2C-LCD-and-Keypad-F_Cu.gbr deleted: build/Raspberry-I2C-LCD-and-K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
2019-08-25 modified: README.md new file: doc/DisplayController.svg new file: doc/KeypadController.svg new file: doc/RasPiInterface.svg new file: doc/Raspberry-I2C-LCD-and-Keypad.svg renamed: gerber/Raspberry-I2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
2019-10-05 new file: "Ras\303\274berry-I2C-cable-cache.lib" new file: "Ras\303\274berry-I2C-cable.pro" new file: "Ras\303\274berry-I2C-cable.sch" new file: doc/GPIOpinout_RB2b.fodt modified: fp-info-cache delet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
